# Keil uVision project STM32F103VE_SONIC_V1.0.uvprojx, settings and files
target STM32F103VE_SONIC_V1.0 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103VE_SONIC +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\CMSIS;..\USER;..\FWlib\inc;..\FWlib\src;.\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ./src/: main.c stm32f10x_it.c Tim2.c usart1.c Sonic.c SysTick.c led.c Tim4.c
  group FWlib
    ../FWlib/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_exti.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group Readme
    ../: Readme.txt
software components: CMSIS:CORE 4.3.0
