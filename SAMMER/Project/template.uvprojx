# Keil uVision project template.uvprojx, settings and files
target demo (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: ..\Library\inc;..\Core;..\User;..\User;..\Hardware\Usart1;..\App\Util;..\Hardware\Led;..\Hardware\SoftI2c;..\Hardware\Hmc5883l;..\Hardware\Mpu6050;..\Hardware\Ms5611;..\App\Debug;..\App\Calibration;..\Hardware\Usart2;..\App\ErrorProcessing;..\App\QuickSort;..\App\Imu;..\Hardware\Timer2;..\App\Control;..\App\Sensor;..\Hardware\Wdog;..\App\Altitude;..\Hardware\PixelFlow;..\Hardware\LowSpeedSoftIic;..\App\Pid;..\App\Filter;..\Hardware\Beep;..\Hardware\InputCapture;..\App\Rc;..\Hardware\Key;..\Hardware\Timer8Pwm;..\Hardware\Timer1;..\App\LandAndTakeOff;..\Hardware;..\Hardware;..\System\SysTick;..\System\Sys;..\System\Sys;..\App;..\App;..\Hardware
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Core
    ../Core/: core_cm3.c startup_stm32f10x_hd.s
  group Library
    ../Library/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group System
    ../System/Sys/: system.h
    ../System/SysTick/: systick.c
  group Hardware
    ../Hardware/: bsp_adc.c bsp_Timbase.c bsp_GeneralTime.c bsp_usart.c usart1_dma.c bsp_SysTick.c bsp_gpio.c bsp_encoder_Tim2.c bsp_encoder_Tim3.c bsp_PWM_Tim1.c
  group User
    ../User/: main.c stm32f10x_it.c system_stm32f10x.c
  group App
    ../App/: bsp_pid.c bsp_control.c
  group Doc
    ../Doc/: readme.txt
